# IAR project SAM4S_V_ADC.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel ATSAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __INTRINSICS_INCLUDED
  ICCARM.CCIncludePath2: ..\src; ..\..\__include; ..\..\__include\Devices\_cores\CMSIS\include; ..\..\__ValidLibs; ..\..\__include\ASF_compliance; ..\..\__ASF\sam
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SAM4S_V_ADC.bin
  postbuild: SAM4S_V_ADC_pb.bat FLASH\Exe\SAM4S_V_ADC.bin
  ILINK.IlinkOutputFile: SAM4S_V_ADC.out
  ILINK.IlinkIcfFile: ..\..\__Link\IAR\SAM4S16_FLASH_default.icf
  ILINK.IlinkExtraOptions: --keep=__checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ICE (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\__Link\IAR\SAM4S4_ISRAM_default.icf
configuration ISRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __INTRINSICS_INCLUDED; _LINK_TO_ISRAM_
  ILINK.IlinkIcfFile: ..\..\__Link\IAR\SAM4S16_ISRAM_default.icf
  group SAM4S_V_ADC_MAIN
    ../src/: main.c menu.c project.h
  group xLibs/ASF
    ../../__ASF/sam/drivers/pio/: pio.c
    ../../__ASF/sam/drivers/pmc/: pmc.c
    ../../__ASF/sam/drivers/rstc/: rstc.c
    ../../__ASF/sam/drivers/uart/: uart.c
  group xLibs/Validation
    ../../__ValidLibs/: v_debug.c v_it_management.c v_utils.c
  group xLibs/Validation/Drivers
    ../../__ValidLibs/v_drivers/: v_nvic.c v_pio.c v_pmc.c v_supc.c v_usart.c v_wdt.c
  group xLibs/Validation/Startup
    ../../__ValidLibs/v_startup/: IAR_SAM3S_cstartup.c v_relocate.c
  group xRessource
    ../../__Link/IAR/: SAM4S16_FLASH_default.icf SAM4S16_ISRAM_default.icf
    ../../: SAM4S_V_ADC_readme.txt
    ../: template_readme.txt
